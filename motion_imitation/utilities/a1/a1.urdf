Commit message: changing remote to GitHub

File: motion_imitation/utilities/a1/a1.urdf (robot description, URDF)
Before this commit: robot a1_description, 18 links, 17 joints
Links:
- link trunk: mass 4.713 -> 8
